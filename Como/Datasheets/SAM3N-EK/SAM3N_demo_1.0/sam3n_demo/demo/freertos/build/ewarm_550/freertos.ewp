# IAR project freertos.ewp, settings and files
configuration flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  ICCARM.CCDefines: sam3n4; flash; TRACE_LEVEL=4; NOFPUT; SAM_PORTING=SAM_PORTING_FREERTOS
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ../../../../libraries; ../../../../libraries/freertos; ../../../../libraries/libqtouch; ../../../../libraries/libboard_sam3n-ek; ../../../../libraries/libchip_sam3n; ../../source; ../../source/qdebug
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: sam3n4; flash; sam3n4; __ASSEMBLY__
  AARM.AUserIncludes: ..\..\..\libraries; ..\..\..\libraries\peripherals; ..\..\..\libraries\board\
  OBJCOPY.OOCOutputFile: demo_sam3n4_flash.bin
  ILINK.IlinkOutputFile: demo_sam3n4_ek_flash.out
  ILINK.IlinkIcfFile: ../../../../libraries/libboard_sam3n-ek/resources/ewarm/sam3n4/flash_demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group documentation
    $EW_DIR$/arm/examples/Atmel/: flashloaders.html
  group libraries
    ../../../../libraries/libboard_sam3n-ek/lib/: libboard_sam3n_ek_ewarm_dbg.a
    ../../../../libraries/libchip_sam3n/lib/: libchip_sam3n4_ewarm_dbg.a
    ../../../../libraries/freertos/lib/: libfreertos_ewarm_dbg.a
    ../../../../libraries/libqtouch/lib/: libqtouch_sam3n_ewarm_rel.a
  group resources
    ../../../../libraries/libboard_sam3n-ek/resources/ewarm/sam3n4/: flash_demo.icf
  group source
    ../../source/: background.c main.c spim_master_wrapper.c test_lcd.c test_qtouch.c
  group source/qdebug
    ../../source/qdebug/: BitBangSPI_Master.c QDebug.c QDebugTransport.c
