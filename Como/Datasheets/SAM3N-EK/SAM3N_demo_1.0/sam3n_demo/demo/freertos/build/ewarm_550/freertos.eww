<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\freertos.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\libraries\libboard_sam3n-ek\build\ewarm_550\libboard_sam3n-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\libraries\libchip_sam3n\build\ewarm_550\libchip_sam3n4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\libraries\freertos\build\ewarm_550\libfreertos.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>flash</name>
      <member>
        <project>libchip_sam3n4</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sam3n-ek</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libfreertos</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>freertos</project>
        <configuration>flash</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sram</name>
      <member>
        <project>libchip_sam3n4</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sam3n-ek</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libfreertos</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>freertos</project>
        <configuration>flash</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


