<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\libboard_sam3n-ek\build\ewarm_550\libboard_sam3n-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\libchip_sam3n\build\ewarm_550\libchip_sam3n1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\libchip_sam3n\build\ewarm_550\libchip_sam3n2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\libchip_sam3n\build\ewarm_550\libchip_sam3n4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\freertos\build\ewarm_550\libfreertos.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>libboard_sam3n-ek</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sam3n-ek</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libchip_sam3n1</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam3n1</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libchip_sam3n2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam3n2</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libchip_sam3n4</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam3n4</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libfreertos</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libfreertos</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


