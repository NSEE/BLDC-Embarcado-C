# Keil uVision project libchip_sam3n2.uvproj, settings and files
target libchip_sam3n2 - Debug (ARM-ADS)
  device: SAM3N2C Atmel
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x400000-0x41FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: libchip_sam3n2_mdk_dbg (library)
  AfterMake: cmd /c "move /Y .\sam3n2_debug\libchip_sam3n2_mdk_dbg.lib ..\..\lib"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: sam3n2
  c misc: --gnu
  c include: ..\..\include;..\..\;
  memory RVCT4: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group cmsis
    ../../cmsis/: core_cm3.c core_cm3.h
  group drivers
    ../../source/: wdt.c adc.c async.c dacc.c efc.c exceptions.c flashd.c pio.c pio_it.c pmc.c pwmc.c rtc.c rtt.c spi.c tc.c twi.c twid.c usart.c
  group include
    ../../include/: wdt.h adc.h async.h dacc.h efc.h exceptions.h flashd.h pio.h pio_it.h pmc.h pwmc.h rtc.h rtt.h SAM3N.h spi.h tc.h trace.h twi.h twid.h usart.h
target libchip_sam3n2 - Release (ARM-ADS)
  device: SAM3N2C Atmel
  cpu: as above
  output: libchip_sam3n2_mdk_rel (library)
  AfterMake: cmd /c "move /Y .\sam3n2_release\libchip_sam3n2_mdk_rel.lib ..\..\lib"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: sam3n2
  c misc: --gnu
  c include: ..\..\include;..\..\;
  memory RVCT4: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
