# IAR project libchip_sam3n1.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: SAM3N1 Atmel SAM3N1
  ICCARM.CCDefines: sam3n1; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: ../../; ../../cmsis
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: libsam3n.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  ICCARM.CCDefines: NDEBUG; sam3n1; TRACE_LEVEL=1
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libchip_sam3n.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: chip.h
  group cmsis
    ../../cmsis/: core_cm3.c core_cm3.h
  group include
    ../../include/: adc.h async.h dacc.h efc.h exceptions.h flashd.h pio.h pio_it.h pmc.h pwmc.h rtc.h rtt.h SAM3N.h spi.h tc.h trace.h twi.h twid.h usart.h wdt.h
  group source
    ../../source/: adc.c async.c dacc.c efc.c exceptions.c flashd.c pio.c pio_it.c pmc.c pwmc.c rtc.c rtt.c spi.c tc.c twi.c twid.c usart.c wdt.c
