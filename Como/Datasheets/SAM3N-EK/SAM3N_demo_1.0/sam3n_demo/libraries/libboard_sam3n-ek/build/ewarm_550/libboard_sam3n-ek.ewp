# IAR project libboard_sam3n-ek.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  ICCARM.CCDefines: sam3n4; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: ../../; ../../../libchip_sam3n/
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: sam3n4
  ILINK.IlinkOutputFile: libsam3n.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sam3n4; TRACE_LEVEL=1
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libboard_sam3n-ek.out
  group (top)
    ../../: board.h
  group include
    ../../include/: bitbanding.h board_lowlevel.h clock.h frame_buffer.h hamming.h ili9225.h iso7816_4.h lcd_color.h led.h math.h sd_spid.h sdmmc_crc.h sdmmc_spi.h timetick.h uart_console.h
  group source
    ../../source/: at25d.c board_cstartup_iar.c board_lowlevel.c clock.c frame_buffer.c hamming.c ili9225.c iso7816_4.c led.c math.c rand.c sd_spid.c sdmmc_crc.c sdmmc_spi.c spi_master.c timetick.c trace.c uart_console.c
