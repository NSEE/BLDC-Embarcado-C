# Keil uVision project libboard_sam3n-ek.uvproj, settings and files
target libboard_sam3n_ek Debug (ARM-ADS)
  device: SAM3N4C Atmel
  cpu: IRAM(0x20000000-0x20005FFF) IROM(0x400000-0x43FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: libboard_sam3n_ek_mdk_dbg (library)
  AfterMake: cmd /c "move /Y .\sam3n_ek_debug\libboard_sam3n_ek_mdk_dbg.lib ..\..\lib"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: sam3n4 TRACE_LEVEL=3
  c misc: --gnu
  c include: ./../..;./../../../libchip_sam3n
  memory RVCT4: ROM 0x400000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group source
    ../../source/: at25d.c board_cstartup_keil.c board_lowlevel.c clock.c frame_buffer.c hamming.c ili9225.c iso7816_4.c led.c math.c rand.c spi_master.c timetick.c trace.c uart_console.c retarget.c sdmmc_spi.c sd_spid.c sdmmc_crc.c
  group include
    ../../include/: at25d.h bitbanding.h board_lowlevel.h clock.h frame_buffer.h hamming.h ili9225.h iso7816_4.h lcd_color.h led.h math.h rand.h spi_master.h timetick.h uart_console.h sdmmc_spi.h sd_spid.h sdmmc_crc.h
target libboard_sam3n_ek Release (ARM-ADS)
  device: SAM3N4C Atmel
  cpu: as above
  output: libboard_sam3n_ek_mdk_rel (library)
  AfterMake: cmd /c "move /Y .\sam3n_ek_release\libboard_sam3n_ek_mdk_rel.lib ..\..\lib"
  c flags: Optim=4 OneElfS=1
  c define: sam3n4 TRACE_LEVEL=3
  c misc: --gnu
  c include: ./../..;./../../../libchip_sam3n
  memory RVCT4: ROM 0x400000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
