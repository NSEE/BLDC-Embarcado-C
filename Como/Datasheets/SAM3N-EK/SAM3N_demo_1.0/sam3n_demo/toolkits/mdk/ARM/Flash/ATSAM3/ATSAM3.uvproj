# Keil uVision project ATSAM3.uvproj, settings and files
target ATSAM3N_256 (ARM-ADS)
  device: ATSAM3U4E Atmel
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ATSAM3N_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM3N_256 FLASH_MEM
  memory RVCT4: ROM 0x80000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target ATSAM3S_256 (ARM-ADS)
  device: ATSAM3U4E Atmel
  cpu: as above
  output: ATSAM3S_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM3S_256 FLASH_MEM
  memory RVCT4: ROM 0x80000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAM3U_128 (ARM-ADS)
  device: ATSAM3U4E Atmel
  cpu: as above
  output: ATSAM3U_128
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM3U_128 FLASH_MEM
  memory RVCT4: ROM 0x80000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAM3U_128_B1 (ARM-ADS)
  device: ATSAM3U4E Atmel
  cpu: as above
  output: ATSAM3U_128_B1
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM3U_128_B1 FLASH_MEM
  memory RVCT4: ROM 0x80000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAM3N_GPNVM (ARM-ADS)
  device: ATSAM3U4E Atmel
  cpu: as above
  output: ATSAM3N_GPNVM
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM3N_256 FLASH_GPNVM
  memory RVCT4: ROM 0x80000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAM3S_GPNVM (ARM-ADS)
  device: ATSAM3U4E Atmel
  cpu: as above
  output: ATSAM3S_GPNVM
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM3S_256 FLASH_GPNVM
  memory RVCT4: ROM 0x80000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAM3U_GPNVM (ARM-ADS)
  device: ATSAM3U4E Atmel
  cpu: as above
  output: ATSAM3U_GPNVM
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAM3U_128 FLASH_GPNVM
  memory RVCT4: ROM 0x80000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
