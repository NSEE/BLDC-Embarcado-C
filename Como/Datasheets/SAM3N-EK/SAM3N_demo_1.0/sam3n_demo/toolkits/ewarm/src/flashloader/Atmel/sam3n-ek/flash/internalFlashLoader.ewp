# IAR project internalFlashLoader.ewp, settings and files
configuration internalFlashSAM3N4 (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  ICCARM.CCDefines: sam3n4; sram; TRACE_LEVEL=0
  ICCARM.CCIncludePath2: $PROJ_DIR$; include; $TOOLKIT_DIR$\src\flashloader\framework2; ..\interface
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: internalFlashLoader.srec
  ILINK.IlinkOutputFile: ..\..\..\..\..\config\flashloader\Atmel\sam3n4\internalflash-sam3n4.out
  ILINK.IlinkIcfFile: mapping\sam3n4_sram_flashloader.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
configuration internalFlashSAM3N2 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3N2 Atmel SAM3N2
  ICCARM.CCDefines: sam3n2; sram; TRACE_LEVEL=0
  ILINK.IlinkOutputFile: ..\..\..\..\..\config\flashloader\atmel\sam3n2\internalflash-sam3n2.out
  ILINK.IlinkIcfFile: mapping\sam3n2_sram_flashloader.icf
configuration internalFlashSAM3N1 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3N1 Atmel SAM3N1
  ICCARM.CCDefines: sam3n1; sram; TRACE_LEVEL=0
  ILINK.IlinkOutputFile: ..\..\..\..\..\config\flashloader\Atmel\sam3n1\internalflash-sam3n1.out
  ILINK.IlinkIcfFile: mapping/sam3n1_sram_flashloader.icf
  group (top)
    include/: chip.h efc.h flashd.h SAM3N1.h SAM3N2.h SAM3N4.h
    src/: efc.c flashd.c
    ./: flash_config.h internalFlashLoader.c
    ../interface/: Interface.c
  group framework
    $EW_DIR$/arm/src/flashloader/framework2/: flash_loader.c flash_loader_asm.s
  group mapping
    mapping/: sam3n1_sram_flashloader.icf sam3n2_sram_flashloader.icf sam3n4_sram_flashloader.icf
