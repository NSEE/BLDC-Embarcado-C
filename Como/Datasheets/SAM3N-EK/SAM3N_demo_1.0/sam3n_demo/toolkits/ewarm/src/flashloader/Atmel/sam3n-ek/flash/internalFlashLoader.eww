<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\internalFlashLoader.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>internalFlash-flashloader</name>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM3N1</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM3N2</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM3N4</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


